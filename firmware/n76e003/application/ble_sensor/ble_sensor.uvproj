# Keil uVision project ble_sensor.uvproj, settings and files
target ble_sensor (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: ble_sensor +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\..\Include
  group Source
    ./Source/: ble_sensor.c
  group Startup
    ../../Startup/: STARTUP.A51
